# Keil uVision project lab1.uvprojx, settings and files
target lab1.0 (6220000::V6.22::ARMCLANG)
  device: S6E2CCAJ0A Cypress
  pack: Keil.FM4_DFP.1.6.0
  cpu: IRAM(0x1FFD0000,0x30000) IRAM2(0x20038000,0x10000) IROM(0x00000000,0x200000) IROM2(0x00406000,0xA000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lab1
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\src;..\hal\include;..\bsp\include
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x406000 size 0xa000
  memory RVCT9: RAM 0x1ffd0000 size 0x30000
  memory RVCT10: RAM 0x20038000 size 0x10000
  group src
    ../src/: lab1.0.c lab1.1.c
  group hal
    ../hal/src/: HAL_FM4_gpio.c
  group bsp
    ../bsp/src/: FM4_leds_sw.c
target lab1.1 (6220000::V6.22::ARMCLANG)
  device: S6E2CCAJ0A Cypress
  pack: Keil.FM4_DFP.1.6.0
  cpu: as above
  output: lab1
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\src;..\hal\include;..\bsp\include
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x406000 size 0xa000
  memory RVCT9: RAM 0x1ffd0000 size 0x30000
  memory RVCT10: RAM 0x20038000 size 0x10000
software components: CMSIS:CORE 6.1.0, Device:Startup 1.0.0
